# IAR project ble_dls_e73-2g4m08s1c_s140.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_CUSTOM; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; NRF_SD_BLE_API_VERSION=7; S140; SOFTDEVICE_PRESENT; DEBUG; xLESC_DEBUG_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\..\..\components\softdevice\s140\headers\nrf52; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\nrf_oberon\include; ..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config; ..\..\..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; NRF_SD_BLE_API_VERSION=7; S140; SOFTDEVICE_PRESENT
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\experimental_task_manager; ..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\gfx; ..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mpu; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sdcard; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\spi_mngr; ..\..\..\..\..\..\components\libraries\stack_guard; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\twi_mngr; ..\..\..\..\..\..\components\libraries\twi_sensor; ..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\components\nfc\ndef\launchapp; ..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\components\nfc\ndef\text; ..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\components\nfc\platform; ..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\components\nfc\t4t_parser\apdu; ..\..\..\..\..\..\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\..\components\nfc\t4t_parser\tlv; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\..\..\components\softdevice\s140\headers\nrf52; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\external\utf_converter; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: ble_dls_nrf52840_s140.hex
  ILINK.IlinkOutputFile: ble_dls_nrf52840_s140.out
  ILINK.IlinkIcfFile: ble_dls_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_CUSTOM; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA; NRF_SD_BLE_API_VERSION=7; S140; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_advertising; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\ble\ble_racp; ..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_ans_c; ..\..\..\..\..\..\components\ble\ble_services\ble_bas; ..\..\..\..\..\..\components\ble\ble_services\ble_bas_c; ..\..\..\..\..\..\components\ble\ble_services\ble_cscs; ..\..\..\..\..\..\components\ble\ble_services\ble_cts_c; ..\..\..\..\..\..\components\ble\ble_services\ble_dfu; ..\..\..\..\..\..\components\ble\ble_services\ble_dis; ..\..\..\..\..\..\components\ble\ble_services\ble_gls; ..\..\..\..\..\..\components\ble\ble_services\ble_hids; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs; ..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_hts; ..\..\..\..\..\..\components\ble\ble_services\ble_ias; ..\..\..\..\..\..\components\ble\ble_services\ble_ias_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs; ..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_lls; ..\..\..\..\..\..\components\ble\ble_services\ble_nus; ..\..\..\..\..\..\components\ble\ble_services\ble_nus_c; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs; ..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c; ..\..\..\..\..\..\components\ble\ble_services\ble_tps; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\ble\nrf_ble_gatt; ..\..\..\..\..\..\components\ble\nrf_ble_qwr; ..\..\..\..\..\..\components\ble\peer_manager; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\atomic_flags; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bootloader\ble_dfu; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\components\libraries\crc16; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\..\components\libraries\csense; ..\..\..\..\..\..\components\libraries\csense_drv; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\ecc; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\experimental_task_manager; ..\..\..\..\..\..\components\libraries\fds; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\gfx; ..\..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hci; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mpu; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwm; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sdcard; ..\..\..\..\..\..\components\libraries\sensorsim; ..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\spi_mngr; ..\..\..\..\..\..\components\libraries\stack_guard; ..\..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\twi_mngr; ..\..\..\..\..\..\components\libraries\twi_sensor; ..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\components\libraries\usbd\class\audio; ..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\components\libraries\usbd\class\hid; ..\..\..\..\..\..\components\libraries\usbd\class\hid\generic; ..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd; ..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse; ..\..\..\..\..\..\components\libraries\usbd\class\msc; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\common; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\components\nfc\ndef\launchapp; ..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\components\nfc\ndef\text; ..\..\..\..\..\..\components\nfc\ndef\uri; ..\..\..\..\..\..\components\nfc\platform; ..\..\..\..\..\..\components\nfc\t2t_lib; ..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\components\nfc\t4t_lib; ..\..\..\..\..\..\components\nfc\t4t_parser\apdu; ..\..\..\..\..\..\components\nfc\t4t_parser\cc_file; ..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\..\..\components\nfc\t4t_parser\tlv; ..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\components\softdevice\s140\headers; ..\..\..\..\..\..\components\softdevice\s140\headers\nrf52; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\nrf_oberon\include; ..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\external\utf_converter; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config; ..\..\..\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: ble_app_template_pca10056_s140.hex
  ILINK.IlinkOutputFile: ble_app_template_pca10056_s140.out
  group Application
    ../../../src/: ble_dls.c ble_dls.h custom_board.h disp.c disp.h geo_location.h isoc.c isoc.h lora-defs.h main.c ubx.c ubx.h
    ../config/: sdk_config.h
  group Application/DebugMonitorMode
    ../../../src/: JLINK_MONITOR.c JLINK_MONITOR.h JLINK_MONITOR_ISR_IAR.s
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_cc310_Crypto
    ../../../../../../external/nrf_cc310/lib/cortex-m4/hard-float/: libnrf_cc310_0.9.13.a
  group nRF_Crypto
    ../../../../../../components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_init.c nrf_crypto_rng.c
  group nRF_Crypto backend cc310
    ../../../../../../components/libraries/crypto/backend/cc310/: cc310_backend_aes_aead.c cc310_backend_ecc.c cc310_backend_ecdh.c cc310_backend_init.c cc310_backend_mutex.c cc310_backend_rng.c cc310_backend_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_ecc.c oberon_backend_ecdh.c
  group nRF_Drivers
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_uarte.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c
    ../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/: liboberon_3.0.8.a
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
