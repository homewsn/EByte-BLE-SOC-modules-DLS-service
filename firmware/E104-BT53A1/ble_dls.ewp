# IAR project ble_dls.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG22C112F352GM32 SiliconLaboratories EFR32BG22C112F352GM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG_EFM=1; EFR32BG22C112F352GM32=1; SL_COMPONENT_CATALOG_PRESENT=1; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; SLI_RADIOAES_REQUIRES_MASKING=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; config; .; gecko_sdk_4.0.0\platform\Device\SiliconLabs\EFR32BG22\Include; gecko_sdk_4.0.0\app\common\util\app_assert; gecko_sdk_4.0.0\platform\common\inc; gecko_sdk_4.0.0\protocol\bluetooth\inc; gecko_sdk_4.0.0\platform\bootloader; gecko_sdk_4.0.0\platform\bootloader\api; gecko_sdk_4.0.0\platform\CMSIS\Include; gecko_sdk_4.0.0\util\third_party\crypto\sl_component\sl_cryptoacc_library\include; gecko_sdk_4.0.0\platform\service\device_init\inc; gecko_sdk_4.0.0\platform\emdrv\common\inc; gecko_sdk_4.0.0\platform\emlib\inc; gecko_sdk_4.0.0\platform\emlib\host\inc; gecko_sdk_4.0.0\platform\service\hfxo_manager\inc; gecko_sdk_4.0.0\util\third_party\crypto\sl_component\sl_mbedtls_support\config; gecko_sdk_4.0.0\util\third_party\crypto\mbedtls\include; gecko_sdk_4.0.0\util\third_party\crypto\mbedtls\library; gecko_sdk_4.0.0\util\third_party\crypto\sl_component\sl_mbedtls_support\inc; gecko_sdk_4.0.0\platform\emdrv\nvm3\inc; gecko_sdk_4.0.0\platform\service\power_manager\inc; gecko_sdk_4.0.0\util\third_party\crypto\sl_component\sl_psa_driver\inc; gecko_sdk_4.0.0\platform\radio\rail_lib\common; gecko_sdk_4.0.0\platform\radio\rail_lib\protocol\ble; gecko_sdk_4.0.0\platform\radio\rail_lib\protocol\ieee802154; gecko_sdk_4.0.0\platform\radio\rail_lib\protocol\zwave; gecko_sdk_4.0.0\platform\radio\rail_lib\chip\efr32\efr32xg2x; gecko_sdk_4.0.0\platform\radio\rail_lib\plugin\pa-conversions; gecko_sdk_4.0.0\platform\radio\rail_lib\plugin\pa-conversions\efr32xg22; gecko_sdk_4.0.0\util\third_party\crypto\sl_component\se_manager\inc; gecko_sdk_4.0.0\util\third_party\crypto\sl_component\se_manager\src; gecko_sdk_4.0.0\util\silicon_labs\silabs_core\memory_manager; gecko_sdk_4.0.0\platform\common\toolchain\inc; gecko_sdk_4.0.0\platform\service\system\inc; gecko_sdk_4.0.0\platform\service\sleeptimer\inc; gecko_sdk_4.0.0\util\third_party\crypto\sl_component\sl_protocol_crypto\src; autogen
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_dls.s37
  ILINK.IlinkOutputFile: ble_dls.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: ble_dls.ipcf
  group Simplicity Configurator
    ./: app.c app.h ble_dls.h disp.c disp.h geo_location.h isoc.c isoc.h lora-defs.h main.c ubx.c ubx.h
  group Simplicity Configurator/autogen
    autogen/: .crc_config.crc gatt_db.c gatt_db.h linkerfile.icf mbedtls_config_autogen.h psa_crypto_config_autogen.h RTE_Components.h sl_application_type.h sl_bluetooth.c sl_bluetooth.h sl_component_catalog.h sl_device_init_clocks.c sl_event_handler.c sl_event_handler.h sl_mbedtls_config_transform_autogen.h sl_power_manager_handler.c
  group Simplicity Configurator/config
    config/: app_assert_config.h app_properties_config.h emlib_core_debug_config.h mbedtls_config.h nvm3_default_config.h psa_crypto_config.h sl_bluetooth_advertiser_config.h sl_bluetooth_config.h sl_bluetooth_connection_config.h sl_device_init_dcdc_config.h sl_device_init_emu_config.h sl_device_init_hfxo_config.h sl_device_init_lfrco_config.h sl_hfxo_manager_config.h sl_memory_config.h sl_power_manager_config.h sl_rail_util_pa_config.h sl_sleeptimer_config.h
  group Simplicity Configurator/config/btconf
    config/btconf/: gatt_configuration.btconf
  group Simplicity Configurator/gecko_sdk_4.0.0/app/common/util/app_assert
    gecko_sdk_4.0.0/app/common/util/app_assert/: app_assert.h sl_app_assert.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/bootloader/api
    gecko_sdk_4.0.0/platform/bootloader/api/: application_properties.h btl_errorcode.h btl_interface.c btl_interface.h btl_interface_parser.h btl_interface_storage.c btl_interface_storage.h btl_reset_info.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/bootloader/app_properties
    gecko_sdk_4.0.0/platform/bootloader/app_properties/: app_properties.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/CMSIS/Include
    gecko_sdk_4.0.0/platform/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/common/inc
    gecko_sdk_4.0.0/platform/common/inc/: sl_atomic.h sl_enum.h sl_slist.h sl_status.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/common/src
    gecko_sdk_4.0.0/platform/common/src/: sl_slist.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/common/toolchain/inc
    gecko_sdk_4.0.0/platform/common/toolchain/inc/: sl_memory.h sl_memory_region.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/common/toolchain/src
    gecko_sdk_4.0.0/platform/common/toolchain/src/: sl_memory.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/Device/SiliconLabs/EFR32BG22/Include
    gecko_sdk_4.0.0/platform/Device/SiliconLabs/EFR32BG22/Include/: efr32bg22_aes.h efr32bg22_agc.h efr32bg22_amuxcp.h efr32bg22_bufc.h efr32bg22_buram.h efr32bg22_burtc.h efr32bg22_cmu.h efr32bg22_cryptoacc.h efr32bg22_dcdc.h efr32bg22_devinfo.h efr32bg22_dma_descriptor.h efr32bg22_dpll.h efr32bg22_emu.h efr32bg22_eusart.h efr32bg22_frc.h efr32bg22_fsrco.h efr32bg22_gpcrc.h efr32bg22_gpio.h efr32bg22_gpio_port.h efr32bg22_hfrco.h efr32bg22_hfxo.h efr32bg22_i2c.h efr32bg22_iadc.h efr32bg22_icache.h efr32bg22_ldma.h efr32bg22_ldmaxbar.h efr32bg22_ldmaxbar_defines.h efr32bg22_letimer.h efr32bg22_lfrco.h efr32bg22_lfxo.h efr32bg22_mailbox.h efr32bg22_modem.h efr32bg22_msc.h efr32bg22_pdm.h efr32bg22_protimer.h efr32bg22_prs.h efr32bg22_prs_signals.h efr32bg22_rac.h efr32bg22_rfcrc.h efr32bg22_rfsense.h efr32bg22_rtcc.h efr32bg22_smu.h efr32bg22_synth.h efr32bg22_syscfg.h efr32bg22_timer.h efr32bg22_ulfrco.h efr32bg22_usart.h efr32bg22_wdog.h efr32bg22c112f352gm32.h em_device.h system_efr32bg22.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/Device/SiliconLabs/EFR32BG22/Source
    gecko_sdk_4.0.0/platform/Device/SiliconLabs/EFR32BG22/Source/: system_efr32bg22.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/Device/SiliconLabs/EFR32BG22/Source/IAR
    gecko_sdk_4.0.0/platform/Device/SiliconLabs/EFR32BG22/Source/IAR/: startup_efr32bg22.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/emdrv/common/inc
    gecko_sdk_4.0.0/platform/emdrv/common/inc/: ecode.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/emdrv/nvm3/inc
    gecko_sdk_4.0.0/platform/emdrv/nvm3/inc/: nvm3.h nvm3_default.h nvm3_hal.h nvm3_hal_flash.h nvm3_lock.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/emdrv/nvm3/lib
    gecko_sdk_4.0.0/platform/emdrv/nvm3/lib/: libnvm3_CM33_iar.a
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/emdrv/nvm3/src
    gecko_sdk_4.0.0/platform/emdrv/nvm3/src/: nvm3_default_common_linker.c nvm3_hal_flash.c nvm3_lock.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/emlib/inc
    gecko_sdk_4.0.0/platform/emlib/inc/: em_assert.h em_burtc.h em_bus.h em_chip.h em_cmu.h em_cmu_compat.h em_common.h em_core.h em_emu.h em_gpio.h em_msc.h em_msc_compat.h em_prs.h em_ramfunc.h em_rtcc.h em_se.h em_system.h em_timer.h em_usart.h em_version.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/emlib/src
    gecko_sdk_4.0.0/platform/emlib/src/: em_assert.c em_burtc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_msc.c em_prs.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/autogen/librail_release
    gecko_sdk_4.0.0/platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg22_iar_release.a
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/chip/efr32/efr32xg2x
    gecko_sdk_4.0.0/platform/radio/rail_lib/chip/efr32/efr32xg2x/: rail_chip_specific.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/common
    gecko_sdk_4.0.0/platform/radio/rail_lib/common/: rail.h rail_assert_error_codes.h rail_features.h rail_mfm.h rail_types.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/plugin/pa-conversions
    gecko_sdk_4.0.0/platform/radio/rail_lib/plugin/pa-conversions/: pa_conversions_efr32.c pa_conversions_efr32.h pa_curve_types_efr32.h pa_curves_efr32.c pa_curves_efr32.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/plugin/pa-conversions/efr32xg22
    gecko_sdk_4.0.0/platform/radio/rail_lib/plugin/pa-conversions/efr32xg22/: sl_rail_util_pa_curves.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/protocol/ble
    gecko_sdk_4.0.0/platform/radio/rail_lib/protocol/ble/: rail_ble.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/protocol/ieee802154
    gecko_sdk_4.0.0/platform/radio/rail_lib/protocol/ieee802154/: rail_ieee802154.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/radio/rail_lib/protocol/zwave
    gecko_sdk_4.0.0/platform/radio/rail_lib/protocol/zwave/: rail_zwave.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/device_init/inc
    gecko_sdk_4.0.0/platform/service/device_init/inc/: sl_device_init_clocks.h sl_device_init_dcdc.h sl_device_init_emu.h sl_device_init_hfxo.h sl_device_init_lfrco.h sl_device_init_nvic.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/device_init/src
    gecko_sdk_4.0.0/platform/service/device_init/src/: sl_device_init_dcdc_s2.c sl_device_init_emu_s2.c sl_device_init_hfxo_s2.c sl_device_init_lfrco.c sl_device_init_nvic.c
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/hfxo_manager/inc
    gecko_sdk_4.0.0/platform/service/hfxo_manager/inc/: sl_hfxo_manager.h sli_hfxo_manager.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/hfxo_manager/src
    gecko_sdk_4.0.0/platform/service/hfxo_manager/src/: sl_hfxo_manager.c sl_hfxo_manager_hal_s2.c sli_hfxo_manager_internal.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/power_manager/inc
    gecko_sdk_4.0.0/platform/service/power_manager/inc/: sl_power_manager.h sl_power_manager_debug.h sli_power_manager.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/power_manager/src
    gecko_sdk_4.0.0/platform/service/power_manager/src/: sl_power_manager.c sl_power_manager_debug.c sl_power_manager_hal_s2.c sli_power_manager_private.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/sleeptimer/inc
    gecko_sdk_4.0.0/platform/service/sleeptimer/inc/: sl_sleeptimer.h sli_sleeptimer.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/sleeptimer/src
    gecko_sdk_4.0.0/platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_burtc.c sl_sleeptimer_hal_prortc.c sl_sleeptimer_hal_rtcc.c sli_sleeptimer_hal.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/system/inc
    gecko_sdk_4.0.0/platform/service/system/inc/: sl_system_init.h sl_system_process_action.h
  group Simplicity Configurator/gecko_sdk_4.0.0/platform/service/system/src
    gecko_sdk_4.0.0/platform/service/system/src/: sl_system_init.c sl_system_process_action.c
  group Simplicity Configurator/gecko_sdk_4.0.0/protocol/bluetooth/inc
    gecko_sdk_4.0.0/protocol/bluetooth/inc/: sl_bgapi.h sl_bt_api.h sl_bt_api_compatibility.h sl_bt_ll_config.h sl_bt_stack_config.h sl_bt_stack_init.h sl_bt_types.h sl_bt_version.h sli_bt_gattdb_def.h
  group Simplicity Configurator/gecko_sdk_4.0.0/protocol/bluetooth/lib/EFR32BG22/IAR
    gecko_sdk_4.0.0/protocol/bluetooth/lib/EFR32BG22/IAR/: libbluetooth.a
  group Simplicity Configurator/gecko_sdk_4.0.0/util/silicon_labs/silabs_core/memory_manager
    gecko_sdk_4.0.0/util/silicon_labs/silabs_core/memory_manager/: sl_malloc.c sl_malloc.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/mbedtls/include/mbedtls
    gecko_sdk_4.0.0/util/third_party/crypto/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_psa.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/mbedtls/include/psa
    gecko_sdk_4.0.0/util/third_party/crypto/mbedtls/include/psa/: crypto.h crypto_builtin_composites.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/mbedtls/library
    gecko_sdk_4.0.0/util/third_party/crypto/mbedtls/library/: bn_mul.h check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h common.h ecp_invasive.h entropy_poll.h md_wrap.h pk_wrap.h platform.c platform_util.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_driver_wrappers.c psa_crypto_driver_wrappers.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h ssl_invasive.h ssl_tls13_keys.h threading.c
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/se_manager/inc
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/se_manager/inc/: sl_se_manager.h sl_se_manager_attestation.h sl_se_manager_check_config.h sl_se_manager_cipher.h sl_se_manager_config.h sl_se_manager_defines.h sl_se_manager_entropy.h sl_se_manager_hash.h sl_se_manager_internal_keys.h sl_se_manager_key_derivation.h sl_se_manager_key_handling.h sl_se_manager_signature.h sl_se_manager_types.h sl_se_manager_util.h sli_se_manager_internal.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/se_manager/src
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/se_manager/src/: sl_se_manager.c sl_se_manager_attestation.c sl_se_manager_cipher.c sl_se_manager_entropy.c sl_se_manager_hash.c sl_se_manager_key_derivation.c sl_se_manager_key_handling.c sl_se_manager_signature.c sl_se_manager_util.c sli_se_manager_osal.h sli_se_manager_osal_baremetal.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_cryptoacc_library/include
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_cryptoacc_library/include/: ba411e_config.h ba413_config.h ba414ep_config.h ba417_config.h ba418_config.h ba431_config.h compiler_extentions.h cryptodma_internal.h cryptolib_def.h cryptolib_types.h sx_aes.h sx_blk_cipher.h sx_blk_cipher_common.h sx_config.h sx_debug.h sx_dh_alg.h sx_dma.h sx_drbg_hash.h sx_ecc_curves.h sx_ecc_keygen_alg.h sx_ecdsa_alg.h sx_errors.h sx_features.h sx_hash.h sx_hw_cfg.h sx_math.h sx_memcmp.h sx_memcpy.h sx_primitives.h sx_rng.h sx_trng.h sxregs.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_cryptoacc_library/src
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_cryptoacc_library/src/: ba414ep_config.c ba431_config.c cryptodma_internal.c cryptolib_types.c sx_aes.c sx_blk_cipher.c sx_dh_alg.c sx_ecc_curves.c sx_ecc_keygen_alg.c sx_ecdsa_alg.c sx_hash.c sx_math.c sx_memcmp.c sx_memcpy.c sx_primitives.c sx_rng.c sx_trng.c
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_mbedtls_support/config
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_mbedtls_support/config/: config-device-acceleration.h config-sl-crypto-all-acceleration.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_mbedtls_support/inc
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_mbedtls_support/inc/: aes_alt.h ccm_alt.h cmac_alt.h gcm_alt.h sha1_alt.h sha256_alt.h sha512_alt.h sl_mbedtls.h threading_alt.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_mbedtls_support/src
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_mbedtls_support/src/: cryptoacc_aes.c cryptoacc_gcm.c mbedtls_ccm.c mbedtls_cmac.c mbedtls_ecdsa_ecdh.c sl_mbedtls.c
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_protocol_crypto/src
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_protocol_crypto/src/: sli_protocol_crypto.h sli_protocol_crypto_radioaes.c sli_radioaes_management.c sli_radioaes_management.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_psa_driver/inc
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_psa_driver/inc/: cryptoacc_management.h sli_cryptoacc_transparent_functions.h sli_cryptoacc_transparent_types.h sli_psa_driver_common.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_psa_driver/inc/psa
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_psa_driver/inc/psa/: error.h internal_trusted_storage.h
  group Simplicity Configurator/gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_psa_driver/src
    gecko_sdk_4.0.0/util/third_party/crypto/sl_component/sl_psa_driver/src/: cryptoacc_management.c sl_psa_its_nvm3.c sli_cryptoacc_transparent_driver_aead.c sli_cryptoacc_transparent_driver_cipher.c sli_cryptoacc_transparent_driver_hash.c sli_cryptoacc_transparent_driver_key_derivation.c sli_cryptoacc_transparent_driver_key_management.c sli_cryptoacc_transparent_driver_mac.c sli_cryptoacc_transparent_driver_signature.c sli_psa_driver_common.c sli_psa_driver_init.c sli_psa_trng.c
